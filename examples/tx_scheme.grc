options:
  parameters:
    generate_options: qt_gui
    id: tx_scheme
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: df
  id: variable_qtgui_range
  parameters:
    start: '-samp_rate/2'
    step: 10e3
    stop: samp_rate/2
    value: '-1.260e6'
  states: {state: disabled}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: '70'
    step: '0.25'
    stop: '6000'
    value: 730 + 1.25
  states: {state: disabled}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.8'
  states: {state: disabled}
- name: pwn_amp
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '3'
    value: '0'
  states: {}
- name: pwn_freq
  id: variable_qtgui_range
  parameters:
    start: '-samp_rate / 2'
    step: 10e3
    stop: samp_rate / 2
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*850000000/8.0)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-1.260e6'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: pwn_amp
    freq: pwn_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 1e6
    type: float
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 200e6
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 2e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 2e6
    win: window.WIN_HAMMING
  states: {}
- name: ntsc_trx_decoder_c_0
  id: ntsc_trx_decoder_c
  parameters:
    samp_rate: samp_rate
  states: {}
- name: ntsc_trx_transmitter_c_0
  id: ntsc_trx_transmitter_c
  parameters:
    samp_rate: samp_rate
  states: {}
- name: ntsc_trx_video_stream_converter_c_0
  id: ntsc_trx_video_stream_converter_c
  parameters:
    decimation_factor: samp_rate / (360 *240 * 60)
    samp_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq*1e6
    gain0: gain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    display_height: 240 * 2
    display_width: 360 * 2
    fps: '0'
    height: '240'
    type: short
    width: '360'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: radio
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: radio
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1, '0', blocks_copy_0, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0, '0']
- [blocks_copy_0, '0', blocks_add_xx_0, '1']
- [blocks_copy_0, '0', qtgui_freq_sink_x_1, '1']
- [blocks_multiply_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_throttle_0, '0', blocks_vco_c_0, '0']
- [blocks_vco_c_0, '0', blocks_add_xx_0, '0']
- [blocks_vco_c_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0, '0', ntsc_trx_decoder_c_0, '0']
- [ntsc_trx_decoder_c_0, '0', ntsc_trx_video_stream_converter_c_0, '0']
- [ntsc_trx_decoder_c_0, '1', ntsc_trx_video_stream_converter_c_0, '1']
- [ntsc_trx_decoder_c_0, '2', ntsc_trx_video_stream_converter_c_0, '2']
- [ntsc_trx_decoder_c_0, '3', ntsc_trx_video_stream_converter_c_0, '3']
- [ntsc_trx_transmitter_c_0, '0', blocks_throttle_0, '0']
- [ntsc_trx_video_stream_converter_c_0, '0', video_sdl_sink_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
